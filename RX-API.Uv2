### uVision2 Project, (C) Keil Software
### Do not modify !

Target (Target 1), 0x0000 // Tools: 'MCS-51'

Group (Source Group 1)

File 1,1,<.\main.c><main.c> 0x0 
File 1,1,<.\SiIAudio.c><SiIAudio.c> 0x0 
File 1,1,<.\SiIDeepColor.c><SiIDeepColor.c> 0x0 
File 1,1,<.\SiIDiagnostic.c><SiIDiagnostic.c> 0x0 
File 1,1,<.\SiIHAL.c><SiIHAL.c> 0x0 
File 1,1,<.\SiIHDCP.c><SiIHDCP.c> 0x0 
File 1,1,<.\SiIHDMIRX.c><SiIHDMIRX.c> 0x0 
File 1,1,<.\SiIInfoPkts.c><SiIInfoPkts.c> 0x0 
File 1,1,<.\SiIISR.c><SiIISR.c> 0x0 
File 1,1,<.\SiIRXIO.c><SiIRXIO.c> 0x0 
File 1,1,<.\SiISW_IIC.c><SiISW_IIC.c> 0x0 
File 1,1,<.\SiISysCtrl.c><SiISysCtrl.c> 0x0 
File 1,1,<.\SiITrace.c><SiITrace.c> 0x0 
File 1,1,<.\SiITTasks.c><SiITTasks.c> 0x0 
File 1,1,<.\SiITTAudio.c><SiITTAudio.c> 0x0 
File 1,1,<.\SiITTHDCP.c><SiITTHDCP.c> 0x0 
File 1,1,<.\SiITTInfoPkts.c><SiITTInfoPkts.c> 0x0 
File 1,1,<.\SiITTVideo.c><SiITTVideo.c> 0x0 
File 1,1,<.\SiIVidF.c><SiIVidF.c> 0x0 
File 1,1,<.\SiIVidIn.c><SiIVidIn.c> 0x0 
File 1,1,<.\SiIVidRes.c><SiIVidRes.c> 0x0 
File 1,1,<.\SiIVRTables.c><SiIVRTables.c> 0x0 
File 1,1,<.\uauddac.c><uauddac.c> 0x0 
File 1,1,<.\UCfgRX.c><UCfgRX.c> 0x0 
File 1,1,<.\UCom.c><UCom.c> 0x0 
File 1,1,<.\UDebugHLIIC.c><UDebugHLIIC.c> 0x0 
File 1,1,<.\UDemoLoader.c><UDemoLoader.c> 0x0 
File 1,1,<.\UEEPROM.c><UEEPROM.c> 0x0 
File 1,1,<.\UInitMCU.c><UInitMCU.c> 0x0 
File 1,1,<.\UKeyboard.c><UKeyboard.c> 0x0 
File 1,1,<.\UMCU_IO.c><UMCU_IO.c> 0x0 
File 1,1,<.\SiIHLIIC.c><SiIHLIIC.c> 0x0 
File 1,1,<.\SiIHLVIIC.c><SiIHLVIIC.c> 0x0 
File 1,1,<.\SiIRX_API.c><SiIRX_API.c> 0x0 


Options 1,0,0  // Target 'Target 1'
 Device (AT89C51ID2)
 Vendor (Atmel)
 Cpu (IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0x6FF) CLOCK(33000000) MODP2)
 FlashUt ("batchisp" (-device $D -hardware RS232 -port COM1 -baudrate 19200 -operation MEMORY FLASH LOADBUFFER %H PROGRAM))
 StupF ("LIB\STARTUP.A51" ("Standard 8051 Startup Code"))
 FlashDR ()
 Rgf (REG51Ix2.H)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 UseEnv=0
 EnvBin ()
 EnvInc ()
 EnvLib ()
 EnvReg (ÿAtmel\)
 OrgReg (ÿAtmel\)
 TgStat=0
 OutDir (.\)
 OutName (RX-API)
 GenApp=1
 GenLib=0
 GenHex=1
 Debug=1
 Browse=1
 LstDir (.\)
 HexSel=0
 MG32K=0
 TGMORE=0
 RunUsr 0 0 <>
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 SVCSID <>
 MODEL5=2
 RTOS5=0
 ROMSZ5=2
 DHOLD5=0
 XHOLD5=0
 T51FL=624
 CBANKS5=0
 XBANKS5=0
 RCB51 { 0,0,0,0,0,255,255,0,0 }
 RXB51 { 0,0,0,0,0,0,0,0,0 }
 OCM51 { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCR51 { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IRO51 { 1,0,0,0,0,0,0,1,0 }
 IRA51 { 0,0,0,0,0,0,1,0,0 }
 XRA51 { 0,0,0,0,0,0,7,0,0 }
 XRA512 { 0,0,0,0,0,0,0,0,0 }
 C51FL=21630224
 C51VA=0
 C51MSC ()
 C51DEF ()
 C51UDF ()
 INCC5 ()
 AX51FL=4
 AX51MSC ()
 AX51SET ()
 AX51RST ()
 INCA5 ()
 PropFld { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 BankNo=65535
 LX51FL=292
 LX51OVL ()
 LX51MSC ()
 LX51DWN ()
 LX51LFI ()
 LX51ASN ()
 LX51RES ()
 LX51CCL ()
 LX51UCL ()
 LX51CSC ()
 LX51UCS ()
 LX51COB ()
 LX51XDB ()
 LX51PDB ()
 LX51BIB ()
 LX51DAB ()
 LX51IDB ()
 LX51PRC ()
 LX51STK ()
 LX51COS ()
 LX51XDS ()
 LX51BIS ()
 LX51DAS ()
 LX51IDS ()
  OPTDL (S8051.DLL)()(DP51.DLL)(-pATID2)(S8051.DLL)()(TP51.DLL)(-pATID2)
  OPTDBG 44029,0,()()()()()()()()()() ()()()()
 FLASH1 { 2,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 FLASH2 ()
 FLASH3 ()
EndOpt

